KERNEL_DEPENDENCY = "virtual/kernel"
KERNEL_DIRECTORY = "${STAGING_KERNEL_DIR}"
KERNEL_BUILD_DIRECTORY = "${STAGING_KERNEL_BUILDDIR}"

require kernel-devsrc.inc
